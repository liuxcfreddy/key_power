# Keil uVision project key_power.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: power +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library;D:\filegame\keil\C51\INC\STC;D:\filegame\keil\C51\INC\User;..\key_power
  group Source Group 1
    ./: STARTUP.A51 main.c
  group library
    ./Library/: config.h EncoderEC11.c EncoderEC11.h STC89C5xRC.h
    ./: adc0832.h adc0832.c
